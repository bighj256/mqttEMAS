# Keil uVision project mqttEMAS.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: mqttEMAS +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 main.c DHT11.c DHT11.h Delay.c Delay.h ESP-01S.c ESP-01S.h
